DESCRIPTION = "Pystache is a Python implementation of Mustache."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=eb4417802c56384aac71b34505528a60"

SRCREV = "17a5dfdcd56eb76af731d141de395a7632a905b8"
SRC_URI = "git://github.com/defunkt/pystache.git"

S = "${WORKDIR}/git"

inherit setuptools3

