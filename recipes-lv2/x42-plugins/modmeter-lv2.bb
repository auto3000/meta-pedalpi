require x42-plugins.inc

SUMMARY = "Audio Signal Level Meter Plugin for the MOD"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "a06806593e719fc8d357ef73a62cab03c11a2f37"
SRC_URI = "git://github.com/x42/modmeter.lv2.git"

