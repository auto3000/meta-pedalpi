require x42-plugins.inc

SUMMARY = "Crude FFT Spectrum Analyzer"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2 fftwf"

SRCREV = "ca8c8b26ebb318a55a60fa9dd6ab2f54e80a7f82"
SRC_URI = "git://github.com/x42/modspectre.lv2.git"

