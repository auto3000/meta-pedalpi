require x42-plugins.inc

SUMMARY = "LV2 Midi Test Sequence Generator"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "3d4171459262ec3ddf27a067ecbe93bdf5ef461e"
SRC_URI = "git://github.com/x42/midigen.lv2.git"

