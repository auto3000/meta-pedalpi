require x42-plugins.inc 

SUMMARY = "Audio to Midi Onset Trigger LV2 Plugin"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "c628e89d9e5b0bacc41ae67fd1c8f2514deb4376"
SRC_URI = "git://github.com/x42/onsettrigger.lv2.git"

