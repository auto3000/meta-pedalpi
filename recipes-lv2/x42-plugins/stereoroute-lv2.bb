require x42-plugins.inc

SUMMARY = "Stereo Routing Plugin"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641e94ec96f98fabc56ff9cc48be14b"

DEPENDS = "lv2"

SRCREV = "136d6e8224788cf88242d48cc6dccbe936dafcf7"
SRC_URI = "git://github.com/x42/stereoroute.lv2.git"

