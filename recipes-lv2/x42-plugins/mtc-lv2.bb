require x42-plugins.inc

SUMMARY = "Midi Timecode Generator"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "c34f31bd14f9e8105d093377119c633fbb1bd1fb"
SRC_URI = "git://github.com/x42/mtc.lv2.git"

