require x42-plugins.inc

SUMMARY = "minimalistic gain control with small MOD GUI"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "7da2876da03a443cb08b27f0c4d3f24633ed91c4"
SRC_URI = "git://github.com/x42/tinyamp.lv2.git"

