require x42-plugins.inc

SUMMARY = "LV2 Control Port Parameter Filters -- modular synth blocks"

SECTION = "multimedia"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641e94ec96f98fabc56ff9cc48be14b"

DEPENDS = "lv2 fftwf"

SRCREV = "4e18641898a8681be914098225f7870401ae1987"
SRC_URI = "git://github.com/x42/controlfilter.lv2.git"

