require x42-plugins.inc

SUMMARY = "Musical Instrument Tuner"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2 fftwf"

SRCREV = "cff95dbafbf03130b2463138f090aee8e842dccf"
SRC_URI = "gitsm://github.com/x42/tuna.lv2.git"

