require x42-plugins.inc

SUMMARY = "LV2 plugins to filter midi events"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641e94ec96f98fabc56ff9cc48be14b"

DEPENDS = "lv2"

SRCREV = "57e937f3132742d96a9654a8424e07c7390923dd"
SRC_URI = "git://github.com/x42/midifilter.lv2.git"

