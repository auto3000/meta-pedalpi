require x42-plugins.inc 

SUMMARY = "DSP tonewheel organ."

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641e94ec96f98fabc56ff9cc48be14b"

DEPENDS = "lv2"

SRCREV = "559b66b5e3d4d73a2baf9c5215f01500e9a28cf1"
SRC_URI = "gitsm://github.com/pantherb/setBfree.git"

