require x42-plugins.inc

SUMMARY = "Stereo Balance Control"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

DEPENDS = "lv2"

SRCREV = "c2ee218f05a2f1fc35b0e2b4f710bf6dea1435fa"
SRC_URI = "git://github.com/x42/balance.lv2.git"

