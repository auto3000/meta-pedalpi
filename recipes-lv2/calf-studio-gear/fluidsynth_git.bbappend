
DEPENDS_append = " readline "

# We don't want pulseaudio in pedalpi
PACKAGECONFIG = " "

