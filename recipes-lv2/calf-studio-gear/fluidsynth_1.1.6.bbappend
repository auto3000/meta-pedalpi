
# We don't want pulseaudio in pedalpi
PACKAGECONFIG = " "

