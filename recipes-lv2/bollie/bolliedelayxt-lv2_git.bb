re bollie.inc

SUMMARY = "Bollie Delay XT"

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d"

DEPENDS = "lv2"

SRCREV = "4f6b8aafd9ed4f20f0cc6750977dcdc57d1fc493"
SRC_URI = "git://github.com/MrBollie/bolliedelayxt.lv2.git"

