require bollie.inc

SUMMARY = "Bollie Delay"

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d"

DEPENDS = "lv2"

SRCREV = "e00d63e5011ac209de3a70bd9a83c7cbb896383a"
SRC_URI = "git://github.com/MrBollie/bolliedelay.lv2.git"

